# Keil uVision project TestRN8209C.uvprojx, settings and files
target TestRN8209C (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: TestRN8209C +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../App/Common;..\App\RN8209C;../App;../App/Uart;../App/Storage;../App/Hard;../App/V9240
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c iwdg.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group App
    ../App/: app_init_variables.c
  group Common
    ../App/Common/: app_global.c app_math.c app_printf.c app_test.c app_tool.c
  group Uart
    ../App/Uart/: app_protocol_ydt1363.c app_responder_ydt.c app_uart_rcv.c
  group Storage
    ../App/Storage/: app_storage.c app_storage_drv.c app_w25qxx.c app_storage_V9240.c app_storage_RN8209C.c
  group Hard
    ../App/Hard/: app_led.c
  group V9240
    ../App/V9240/: V9240_calibrate.c V9240_drv.c V9240_init.c V9240_main.c V9240_read.c V9240_reg.c
  group RN8209C
    ../App/RN8209C/: RN8209C_calibrate.c RN8209C_drv.c RN8209C_init.c RN8209C_main.c RN8209C_read.c RN8209C_reg.c
software components: CMSIS:CORE 4.3.0
